PACKAGE_SNAP_LIB_SYMLINKS = "0"