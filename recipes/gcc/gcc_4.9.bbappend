EXTRA_OECONF += "CFLAGS='-Wno-error=format-security'"
EXTRA_OECONF += "CXXFLAGS='-Wno-error=format-security'"

PACKAGE_SNAP_LIB_SYMLINKS = "0"